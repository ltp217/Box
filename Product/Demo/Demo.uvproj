# Keil uVision project Demo.uvproj, settings and files
target Demo (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_221184
  c include: ..\..\Include
  asm include: ..\..\Include
  group Demo
    ./Code/: demo.c
    ./Startup/: STARTUP.A51
  group Common
    ../../Common/: Delay.c Version.c Semaphore.c Adc.c Clock.c Gpio.c Serial.c
  group Config
    ../../Config/: Conf_tny.A51
  group Documentation
    ./Documentation/: ABSTRACT.TXT
